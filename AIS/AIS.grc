options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: top_block
    output_language: python
    run_options: run
  states: {}

blocks:
- name: bit_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\ztg\Desktop\aistest2.iq
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: T:\project\radio\transfer\ais\type6b.iq8s
    repeat: 'True'
    type: byte
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.4'
    samples_per_symbol: int(samp_rate/bit_rate)
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0
    bb_gain0: '0'
    freq0: '433800000'
    gain0: '0'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', digital_gmsk_mod_0, '0']
- [digital_gmsk_mod_0, '0', blocks_file_sink_0, '0']
- [digital_gmsk_mod_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
